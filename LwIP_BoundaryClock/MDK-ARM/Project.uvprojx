# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_Discovery +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO
  c misc: --C99
  c include: ..\Inc;..\Src;..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32F769I-Discovery;..\..\Drivers\BSP\Components\Common;..\..\Drivers\BSP\Components;..\..\Middlewares\Third_Party\LwIP\src\include;..\..\Middlewares\Third_Party\LwIP\system;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Utilities;..\..\Utilities\Log;..\..\Middlewares\Third_Party\ptpd-2.0.0\src;..\..\Middlewares\Third_Party\ptpd-2.0.0\src\dep
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c
  group Middlewares/LwIP/apps/httpd
    ../../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c tasks.c timers.c list.c
  group Middlewares/FreeRTOS/portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/Utilities
    ../../Utilities/Log/: lcd_log.c
  group Application/User
    ../Src/: ethernetif.c stm32f7xx_hal_timebase_tim.c app_ethernet.c stm32f7xx_it.c httpserver-socket.c main.c dma.c usart.c
  group Middlewares/LwIP/Core/IPv4
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c etharp.c ip4.c autoip.c ip4_addr.c dhcp.c igmp.c ip4_frag.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/BSP/STM32F769I_Discovery
    ../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_lcd.c stm32f769i_discovery.c stm32f769i_discovery_sdram.c
  group Middlewares/LwIP/Core
    ../../Middlewares/Third_Party/LwIP/src/core/: raw.c memp.c inet_chksum.c tcp.c def.c mem.c ip.c netif.c stats.c udp.c pbuf.c sys.c tcp_in.c timeouts.c dns.c tcp_out.c init.c
  group Middlewares/LwIP/Api
    ../../Middlewares/Third_Party/LwIP/src/api/: tcpip.c netdb.c sockets.c api_msg.c netifapi.c netbuf.c api_lib.c err.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/LwIP/Netif
    ../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Ptpd_app
    ../../Middlewares/Third_Party/ptpd-2.0.0/src/: arith.c bmc.c protocol.c ptpd.c
  group Ptpd_platformDependent
    ../../Middlewares/Third_Party/ptpd-2.0.0/src/dep/: msg.c net.c servo.c startup.c sys_time.c timer.c
software components: CMSIS:CORE 4.3.0
